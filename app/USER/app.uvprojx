# Keil uVision project app.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: app +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\HARDWARE;..\STM32F10x_StdPeriph_Driver\inc;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0xd000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group core
    ../CORE/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_md.s
  group user
    ./: main.c
  group hardware
    ../HARDWARE/: delay.c led.c oled.c lcd.c AMG8833.c
  group fwlib
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_i2c.c stm32f10x_dma.c stm32f10x_tim.c stm32f10x_spi.c
